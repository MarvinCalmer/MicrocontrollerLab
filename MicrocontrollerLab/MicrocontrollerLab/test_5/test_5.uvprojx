# Keil uVision project test_5.uvprojx, settings and files
target RAM (6190000::V6.19::ARMCLANG)
  device: LPC1769 NXP
  pack: Keil.LPC1700_DFP.2.7.2
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1
  c define: __TARGET_HW
  c include: ..\Peripherals\include
  memory RVCT4: ROM 0x10000000 size 0x6000
  memory RVCT9: RAM 0x10006000 size 0x2000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: test_5.c
    ../Peripherals/src/: GLCD_SPI_LPC1700.c glcd_simulation.c gpio.c timer.c lcd.c led.c adc.c keys.c
    ../Peripherals/include/: timer.h
target Simulation (6190000::V6.19::ARMCLANG)
  device: LPC1769 NXP
  pack: Keil.LPC1700_DFP.2.7.2
  cpu: as above
  output: test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1
  c include: ..\Peripherals\include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
